# Repository evietron/BackBit-OpenSource (continued)

## KiCad design IBM-PCjr-512KB/kicad/sidecar.kicad_pcb

Parts:
C1, C2: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C3: 10uF; CP_Radial_D6.3mm_P2.50mm
J1: Conn_02x30_Row_Letter_First; edge_pins_60
U1: AS6C4008-55PCN; DIP-32_W15.24mm
U2: 74LS151; DIP-16_W7.62mm_LongPads

Connections:
A0: J1.12, U1.12 (A0)
A1: J1.13, U1.11 (A1)
A2: J1.14, U1.10 (A2)
A3: J1.15, U1.9 (A3)
A4: J1.17, U1.8 (A4)
A5: J1.18, U1.7 (A5)
A6: J1.20, U1.6 (A6)
A7: J1.21, U1.5 (A7)
A8: J1.22, U1.27 (A8)
A9: J1.23, U1.26 (A9)
A10: J1.25, U1.23 (A10)
A11: J1.26, U1.25 (A11)
A12: J1.28, U1.4 (A12)
A13: J1.29, U1.28 (A13)
A14: J1.31, U1.3 (A14)
A15: J1.32, U1.31 (A15)
A16: J1.33, U1.2 (A16)
A17: J1.36, U1.30 (A17), U2.11 (S0)
A18: J1.37, U1.1 (A18), U2.10 (S1)
A19: J1.38, U2.9 (S2)
CE: U1.22 (CE#), U2.6 (~Z)
D0: J1.1, U1.13 (DQ0)
D1: J1.2, U1.14 (DQ1)
D2: J1.4, U1.15 (DQ2)
D3: J1.5, U1.17 (DQ3)
D4: J1.6, U1.18 (DQ4)
D5: J1.7, U1.19 (DQ5)
D6: J1.9, U1.20 (DQ6)
D7: J1.10, U1.21 (DQ7)
GND: C1.2, C2.2, C3.2, J1.8, J1.16, J1.30, J1.34, J1.40, J1.48, J1.56, U1.16 (VSS), U2.4 (I0), U2.7 (~E), U2.8 (GND), U2.12 (I7), U2.13 (I6), U2.14 (I5)
OE: J1.42, U1.24 (OE#)
VCC: C1.1, C2.1, C3.1, J1.11, J1.51, U1.32 (VCC), U2.1 (I3), U2.2 (I2), U2.3 (I1), U2.15 (I4), U2.16 (VCC)
WE: J1.44, U1.29 (WE#)

Board: 2 copper layers, 77.4 x 27.1 mm, 6 parts (0 on the bottom side), 33 nets.

## Code that names these connections

File PLAster128/ise/PLAster128.ucf:

NET "rw" LOC = "P1";
NET "aec" LOC = "P2";
NET "game" LOC = "P4";
NET "xrom" LOC = "P6";
NET "z8en" LOC = "P7";
NET "z8io" LOC = "P8";
NET "ms3" LOC = "P9";
NET "ms2" LOC = "P10";
NET "ms1" LOC = "P11";
NET "ms0" LOC = "P12";
NET "vma4" LOC = "P13";
NET "clk" LOC = "P15";
NET "vicfix" LOC = "P16";
NET "vma5" LOC = "P17";
NET "ba" LOC = "P18";
NET "lram" LOC = "P19";
NET "hram" LOC = "P20";
NET "chre" LOC = "P22";
NET "va14" LOC = "P23";
NET "r256" LOC = "P24";
NET "roml" LOC = "P27";
NET "romh" LOC = "P31";
NET "clrbnk" LOC = "P32";
NET "rom4" LOC = "P33";
NET "rom3" LOC = "P34";
NET "from" LOC = "P35";
NET "rom2" LOC = "P36";
NET "eyes" LOC = "P38";
NET "knlovr" LOC = "P39";
NET "slowxp" LOC = "P40";
NET "rom1" LOC = "P43";
NET "dwe" LOC = "P46";
NET "iocs" LOC = "P48";
NET "casenb" LOC = "P49";
NET "vic" LOC = "P50";
NET "ioacc" LOC = "P51";
NET "gwe" LOC = "P52";
NET "colram" LOC = "P56";
NET "charom" LOC = "P57";
NET "a15" LOC = "P58";
NET "a14" LOC = "P59";
NET "a13" LOC = "P60";
NET "a12" LOC = "P61";
NET "a11" LOC = "P62";
NET "a10" LOC = "P63";

## Commit log

2023-11-11 added c128 diag harness loopback plug
2023-12-01 restored sop memory
2023-12-10 added PLAster128
2024-03-01 Korg 01W LCD fix
2024-03-12 added genassister
2024-03-12 added stls
2024-03-12 unused
2024-03-12 rename
2024-03-19 added plaster 64
2024-06-11 possible equation fix
2024-09-15 Added BBC Micro B Ashtray PCB
