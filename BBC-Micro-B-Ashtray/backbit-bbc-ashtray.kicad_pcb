# Repository evietron/BackBit-OpenSource

File README.md:

# Open Source Hardware for Vintage Computers
## Developed by BackBit (http://backbit.io)

These are some hardware devices that I use for my vintage machines. I used to sell some of these, but I no longer have the bandwidth to build these specfic items so I have made the designs open-source. Designs may have been derived from various information I scrubbed from the internet, but layouts are my own. Feel free to make your own builds, modifications, or to ask me questions about how to build.

## Atari 520ST/1040ST (4MB internal upgrade)

- Details: Expands 520ST or 1040ST to maxmimum 4MB RAM.
- BOM: 2x SMT MSM5118165F-50TK, 2x SMT 0.1uF ceramic capacitors, 1x 33Ω THT resistor, 2x 66Ω THT resistor, round header pins, 16x 16P 0.3" sockets, 4x bodge wires.
- Installation: Mount sockets on main board, route bodge wires. Plug memory board into sockets.

## BBC Micro B: Ashtray (for 28-pin ROM)

- Details: Allows plugging in 28-pin ROMs from the front of your BBC Micro without opening it up (after installed)
- Warning: You might have to cut some capacitors that get in the way of the DIP IDC plug. Also the PCB may require gluing to the inside of the case. Be careful not to chip your keyboard cover when removing the cutout.
- Options: You can use a 26-pin or 30-pin IDC cable (I don't think they make 28-pin, unfortunately). If you only need support for 16K ROMs (and this includes the BackBit cart), you can use 26-pin. For 32K ROMs, you will need 30pin.
- Cable materials: 26 or 30-pin female IDC connector, 28-pin DIP IDC plug, 26 or 30-pin cable (about 1.5-2 feet), crimping tool. If using 26-pin cable, make sure to offset away from pins 1 and 28 of the DIP plug (IC88 / DFS).
- PCB BOM / Instructions: 26-pin or 30-pin Male IDC through hole Socket, 28-pin ZIF socket. Solder "26P" blob if using 26 pin IDC cable. Solder IDC socket first, THEN solder ZIF socket.
- It is tricky to route the cable just right so it does not show through the transparent cover of the keyboard, but it can be done.

## Commodore 64/128 Diagnostic Harness: Keyboard Loopback for 128/128D/SX64

- Details: Provides a keyboard loopback for C128, C128D, and SX64 machines to peform full diagnostic tests
- Note: there are two ways to build --- a reversible C128/C128D loopback, and a SX64 loopback.
- BOM (128/128D): DB25 - male & female connectors (with screws removed), 1x #6x1/2" brass screw, E-Switch LC2259EENP DPDT switch, E-Switch 1SBLK switch cap
- BOM (SX64): DB25 - male connector with cover removed
- Instructions (128/128D): Print Keyboard128 case. Solder DB25 male connector to "DB25-M(8)" side and DB25 female connector to "DB25-M(X)/F(8)" side. Solder DPDT switch. 
- Instructions (SX64): Print KeyboardSX case. Solder "SX64 enable" blob. Solder DB25 male connector (w/ cover removed) to "DB25-M(X)/F(8)" side. Attach to case with super glue, with 13-pin side closer to handle, 12-pin side away from handle.

## GenAssister for (Sega Genesis joystick switcher for Commodore 64/128)

- BOM: 1x SMT ATF1502ASL-25AU44, 1x APEM MHS233 switch, 2x Amphenol LD09S13A4GX00LF DB9 port, 1x Amphenol LD09P13A4GX00LF DB9 port, 1x NE555 SOIC-8, 1x 10Kx7 resistor network, 1x 3mm Red LED, 1x 3mm Yellow LED, 1x 220R resistor, 1x 330R resistor, 1x STX-3000 TRS jack, 1x 100mA polyfuse, 1x 471 SMT capacitor, 7x 100nf SMT Capacitor, 2x 10K SMT capacitor, 1x 15K SMT capacitor.
- Installation: Program CPLD w/ ATDH1150USB programmer.

## IBM PCjr (512KB sidecar expansion)

- Details: Adds 512KB, expanding total system memory to 640KB (if you already have 128KB internally).
- BOM: 1x THT AS6C4008-55PCN/PIN, 2x THT 0.1uF ceramic capacitors, 1x THT 10uF electrolytic capacitor, 1x THT 74LS151 logic chip, 2x30P 2.54mm female header.
- Installation: Plug sidecar into side of machine.

## Korg 01/W LCD Fix

- Details: Adapter to fix the contrast when replacing the Korg 01/W LCD with a modern LED replacement

## Plaster 64 (PLA replacement for Commodore 64)

- Details: Replaces MOS 906114 with exact
 equations used in original device
- CAS delay: Improves compatibility on some systems.
- KERNAL Mode: Switch allows BackBit cartridge (any maybe others) to replace KERNAL ROM.
- Private Eyes Mode: Switch sets bus high to facilitate in-circuit testing.
- BOM: SMT ATF1502ASL-25AU44, 3x 2.54mm DIP switch, 28x header pins, optional 28P socket, and parts assembled on bottom of PCB listed in parts folder.
- Instructions: PCB requires SMT assembly.
- Installation: Program CPLD w/ ATDH1150USB programmer.

## PLAster 128 (PLA replacement for Commodore 128)

- Details: Replaces MOS 8721 with exact equations used in original device
- Compatibility Mode: Switch allows cartridges to work in FAST mode.
- KERNAL Mode: Switch allows BackBit cartridge (any maybe others) to replace KERNAL ROM.
- Private Eyes Mode: Switch sets bus high to facilitate in-circuit testing.
- BOM: XC9572XL-*VQG64C, 3x 2.54mm DIP switch, 48x header pins, optional 48P socket, and parts assembled on bottom of PCB listed in parts folder.
- Instructions: PCB requires SMT assembly.
- Note: There is very limited height inside the C128 and you may want to modify this design to use Flip Pins (http://oshchip.org/products/Flip-Pins_Product)
- Some research credited to: https://c128.se/posts/silicon-adventures/

## Tandy Color Computer 3 (512KB internal upgrade)

- Details: Expands base model's 128KB to 512KB. Timing window is very narrow. RC delay accomodates SRAM to work in place of DRAM.
- BOM: 1x SMT IS61C25616AS-25TLI, 1x SMT ATF1502ASL-25AU44, square header pins.
- Installation: Program CPLD w/ ATDH1150USB programmer. Remove existing RAM chips, plug memory board into expansion headers. Optionally remove ceramic caps C65 and C66.
- Note: I made a late change to the CUPL file to adjust the equations, which could fix some bus contention. I would recommend to test both the previous and current CUPL files to be certain.

## Texas Instruments TI-99/4A (32KB sidecar expansion)

- Details: Fills in the system's memory map to get the maximum non-bankswitched RAM expansion. No pass-through port in this design. Need to add JTAG header if you don't have a programmer with a socket.
- BOM: 1x SMT CY62256NLL-70SNX (SOP-28), 1x SMT ATF1502ASL-25AU44, 5x SMT 0.1uF bypass capacitors, 44P 2.54mm edge connector.
- Installation: Program CPLD w/ ATDH1150USB programmer. Plug sidecar into side of machine.
- Case: https://www.printables.com/model/301498

## KiCad design BBC-Micro-B-Ashtray/backbit-bbc-ashtray.kicad_pcb

Parts:
J1, J4: Conn_01x14; PinHeader_1x14_P2.54mm_Vertical
J2, J3: Conn_01x15; PinSocket_1x15_P2.54mm_Vertical
JP1: 26P; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm

Connections:
unnamed: J1.2, J2.2
unnamed: J1.3, J2.3
unnamed: J1.4, J2.4
unnamed: J1.5, J2.5
unnamed: J1.6, J2.6
unnamed: J1.7, J2.7
unnamed: J1.8, J2.8
unnamed: J1.9, J2.9
unnamed: J1.10, J2.10
unnamed: J1.11, J2.11
unnamed: J1.12, J2.12
unnamed: J1.13, J2.13
unnamed: J1.14, J2.14
unnamed: J3.3, J4.3
unnamed: J3.4, J4.4
unnamed: J3.5, J4.5
unnamed: J3.6, J4.6
unnamed: J3.7, J4.7
unnamed: J3.8, J4.8
unnamed: J3.9, J4.9
unnamed: J3.10, J4.10
unnamed: J3.11, J4.11
unnamed: J3.12, J4.12
unnamed: J3.13, J4.13
unnamed: J3.14, J4.14
PIN1: J1.1, J2.1
PIN27: J3.2, J4.2, JP1.2 (B)
PIN28: J3.1, J4.1, JP1.1 (A)

Board: 2 copper layers, 28.0 x 50.0 mm, 5 parts (1 on the bottom side), 28 nets.

## KiCad design PLAster64/PLAster.kicad_pcb

Parts:
C1, C2, C3, C4: 100nF; C_0402_1005Metric; LCSC C1525
D1, D2, D3, D4, D5, D6, D7, D8: D_Small; D_SOD-323; LCSC C2128
H1, H2: MountingHole; ToolingHole
J1: AVR-JTAG-10; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3: 10K; R_0402_1005Metric; LCSC C25744
R4, R5, R6, R7, R8, R9, R10, R11: 3.3K; R_0402_1005Metric; LCSC C25890
SW1: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W7.62mm_P2.54mm_LowProfile
U1: PLA; DIP-28_W15.24mm
U2: ATF1502AS; TQFP-44_10x10mm_P0.8mm

Connections:
A0: U1.9 (A0), U2.8 (I/O)
A1: U1.8 (A1), U2.6 (I/O)
A2: U1.7 (A2), U2.5 (PD1/I/O)
A3: U1.6 (A3), U2.3 (I/O)
A4: U1.5 (A4), U2.2 (I/O)
A5: U1.4 (A5), U2.44 (I/O)
A6: U1.3 (A6), U2.43 (I/O)
A7: U1.2 (A7), U2.42 (I/O)
A8: U1.27 (A8), U2.35 (GCLK3/I/O)
A9: U1.26 (A9), U2.34 (I/O)
A10: U1.25 (A10), U2.33 (I/O)
A11: U1.24 (A11), U2.31 (I/O)
A12: U1.23 (A12), U2.30 (I/O)
A13: U1.22 (A13), U2.28 (I/O)
A14: U1.21 (A14), U2.27 (I/O)
A15: U1.20 (A15), U2.25 (I/O)
CAS_EXTRA_DELAY: R3.1, SW1.1, U2.18 (I/O)
D0: R4.2, U1.18 (D0), U2.15 (I/O)
D1: R5.2, U1.17 (D1), U2.23 (I/O)
D2: R6.2, U1.16 (D2), U2.22 (I/O)
D3: R7.2, U1.15 (D3), U2.21 (I/O)
D4: R8.2, U1.13 (D4), U2.13 (I/O)
D5: R9.2, U1.12 (D5), U2.12 (I/O)
D6: R10.2, U1.11 (D6), U2.11 (I/O)
D7: R11.2, U1.10 (D7), U2.10 (I/O)
GND: C1.1, C2.1, C3.1, C4.1, J1.2 (GND), J1.10 (GND), R2.2, SW1.5, SW1.6, U1.14 (GND), U2.4 (GND), U2.16 (GND), U2.24 (GND), U2.36 (GND), U2.37 (GCLK1/I), U2.40 (GCLK2/OE2/I)
KERNAL_OVERRIDE: R1.1, SW1.2, U2.19 (PD2/I/O)
unnamed: D1.1 (K), R4.1
unnamed: D2.1 (K), R5.1
unnamed: D3.1 (K), R6.1
unnamed: D4.1 (K), R7.1
unnamed: D5.1 (K), R8.1
unnamed: D6.1 (K), R9.1
unnamed: D7.1 (K), R10.1
unnamed: D8.1 (K), R11.1
PRIVATE_EYES: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), R2.1, SW1.3, U2.20 (I/O)
TCK: J1.1 (TCK), U2.26 (I/O/TCK)
TDI: J1.9 (TDI), U2.1 (I/O/TDI)
TDO: J1.3 (TDO), U2.32 (I/O/TDO)
TMS: J1.5 (TMS), U2.7 (TMS/I/O)
VCC: C1.2, C2.2, C3.2, C4.2, J1.4 (VREF), J1.7 (VCC), R1.2, R3.2, SW1.4, U1.28 (VCC), U2.9 (VCC), U2.17 (VCC), U2.29 (VCC), U2.39 (GCLR/I), U2.41 (VCC)
~CE: U1.19 (~CE), U2.38 (I/OE1)

Board: 2 copper layers, 17.3 x 36.1 mm, 28 parts (23 on the bottom side), 42 nets.

## KiCad design GenAssister/kicad/genesis-to-c64.kicad_pcb

Board: 2 copper layers, 44.5 x 62.5 mm, 23 parts (10 on the bottom side), 40 nets.

Parts:
C1, C2, C3, C4, C5: C; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: YEL; LED_D3.0mm
D2: RED; LED_D3.0mm
F1: 100mA; Fuse
H1: MountingHole; MountingHole_6.4mm_M6
J1: AVR-JTAG-10; PinHeader_2x05_P2.54mm_Vertical
J2: AudioJack3; STX-3000
JIN1: DB9_Male; DB9_MALE_D09P13B4PA00LF
JOUT1, JOUT2: DB9_Female; DB9_FEMALE_D09S33E4GL00LF
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4: 10K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R5: 15K; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
RN1: 10K; R_Array_SIP7
U1: ATF1502AS; TQFP-44_10x10mm_P0.8mm
U2: SW_DP3T; APEM_MHS233_2P3T
U3: NE555D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
AB: JIN1.6, RN1.6 (R5), U1.25 (I/O)
ACT1: D1.2 (A), U1.43 (I/O)
ACT2: D2.2 (A), U1.44 (I/O)
CLK: U1.37 (GCLK1/I), U3.3 (Q)
DISCH: R3.2, R5.1, U3.7 (DIS)
DOWN: JIN1.2, RN1.3 (R2), U1.27 (I/O)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.2 (GND), J1.10 (GND), J2.S, JIN1.8, JOUT1.8, JOUT2.8, R1.1, R2.1, R4.2, U1.4 (GND), U1.16 (GND), U1.24 (GND), U1.36 (GND), U1.38 (I/OE1), U1.40 (GCLK2/OE2/I), U2.1 (1A), U2.3 (1B), U2.8 (2A), U3.1 (GND)
JOY1F2: JOUT1.9, U1.13 (I/O)
JOY1F3: JOUT1.5, U1.12 (I/O)
JOY2F2: JOUT2.9, U1.3 (I/O)
JOY2F3: JOUT2.5, U1.2 (I/O)
LED: J2.T, R4.1, U1.42 (I/O)
LEFT: JIN1.3, RN1.4 (R3), U1.30 (I/O)
MENU: J2.R, U1.35 (GCLK3/I/O)
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: F1.2, JOUT1.7, JOUT2.7
RIGHT: JIN1.4, RN1.5 (R4), U1.31 (I/O)
SELECT: JIN1.7, U1.28 (I/O)
SIG: U1.34 (I/O), U2.4 (1C), U2.5 (2C), U2.6 (2B)
STARTC: JIN1.9, RN1.7 (R6), U1.33 (I/O)
SW1: U1.18 (I/O), U2.7
TCK: J1.1 (TCK), U1.26 (I/O/TCK)
TDI: J1.9 (TDI), U1.1 (I/O/TDI)
TDO: J1.3 (TDO), U1.32 (I/O/TDO)
THRESH: R3.1, U3.2 (TR), U3.6 (THR)
TMS: J1.5 (TMS), U1.7 (TMS/I/O)
UP: JIN1.1, RN1.2 (R1), U1.23 (I/O)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, F1.1, J1.4 (VREF), J1.7 (VCC), JIN1.5, R5.2, RN1.1 (common), U1.9 (VCC), U1.17 (VCC), U1.29 (VCC), U1.39 (GCLR/I), U1.41 (VCC), U3.4 (R), U3.8 (VCC)
~JOY1D: JOUT1.2, U1.20 (I/O)
~JOY1F: JOUT1.6, U1.21 (I/O)
~JOY1L: JOUT1.3, U1.19 (PD2/I/O)
~JOY1R: JOUT1.4, U1.14 (I/O)
~JOY1U: JOUT1.1, U1.22 (I/O)
~JOY2D: JOUT2.2, U1.8 (I/O)
~JOY2F: JOUT2.6, U1.10 (I/O)
~JOY2L: JOUT2.3, U1.6 (I/O)
~JOY2R: JOUT2.4, U1.5 (PD1/I/O)
~JOY2U: JOUT2.1, U1.11 (I/O)
~SW2: U1.15 (I/O), U2.2

## KiCad design Korg-01W-LCD-Fix/contrast.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0603_1608Metric; LCSC C14663
J1: DISPLAY; PinHeader_2x10_P2.54mm_Vertical_SMD
J2: MOTHERBOARD; PinSocket_2x10_P2.54mm_Vertical_SMD
JP1: NO ADJUST; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: FONT_VCC; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3: FONT_GND; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: FONT_MB; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 10K; R_0603_1608Metric; LCSC C25804
RV1: CONTRAST; Potentiometer_Runtron_RM-065_Vertical
U1: 74LS00; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C609793

Connections:
CAP: C1.1, R1.2, U1.4, U1.5
CD: J1.8, J2.8
CE: J1.7, J2.7
DB0: J1.11, J2.11
DB1: J1.12, J2.12
DB2: J1.13, J2.13
DB3: J1.14, J2.14
DB4: J1.15, J2.15
DB5: J1.16, J2.16
DB6: J1.17, J2.17
DB7: J1.18, J2.18
FGND: J1.1, J2.1
FONT: J1.19, JP2.1 (A), JP3.1 (A), JP4.1 (A)
FONTMB: J2.19, JP4.2 (B)
GND: C1.2, C2.2, J1.2, J2.2, JP3.2 (B), RV1.1, U1.7 (GND), U1.12, U1.13
RD: J1.6, J2.6
RST: J2.10, U1.1, U1.2
RSTDISP: J1.10, U1.8
V0: J2.4, JP1.1 (A), RV1.3
V0DISP: J1.4, JP1.2 (B), RV1.2
VCC: C2.1, J1.3, J2.3, JP2.2 (B), U1.14 (VCC)
WR: J1.5, J2.5
~CAP: U1.6, U1.10
~RST: R1.1, U1.3, U1.9

Board: 2 copper layers, 38.2 x 31.0 mm, 11 parts (10 on the bottom side), 24 nets.

## KiCad design PLAster128/PLAster128.kicad_pcb

Parts:
C1, C2, C3, C4: 100nF; C_0402_1005Metric; LCSC C1525
C5, C6: 1uF; C_0805_2012Metric; LCSC C28323
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: 1N4148WS; D_SOD-323; LCSC C2128
FB1: Ferrite_Bead_Small; C_0805_2012Metric; LCSC C1015
J1: AVR-JTAG-10; PinHeader_2x05_P2.54mm_Vertical
J2: Conn_02x24_Counter_Clockwise; DIP-48_W15.24mm
R1, R2, R3: 10K; R_0402_1005Metric; LCSC C25744
R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 3.3K; R_0402_1005Metric; LCSC C25890
SW1: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W7.62mm_P2.54mm_LowProfile
U1: XC6206; SOT-23; LCSC C5446
U2: XC9572XL-VQ64; LQFP-64_10x10mm_P0.5mm

Connections:
64_128: J2.15, U2.9
128_256: J2.27, U2.24
+3V3: C1.2, C2.2, C3.2, C4.2, C6.1, J1.4 (VREF), R1.2, R3.2, U1.2 (VO), U2.3 (VCC), U2.26 (VCCIO), U2.37 (VCC), U2.55 (VCCIO)
+5V: C5.1, FB1.1, SW1.4, U1.3 (VI)
A10: J2.6, U2.63
A11: J2.5, U2.62
A12: J2.4, U2.61
A13: J2.3, U2.60
A14: J2.2, U2.59
A15: J2.1, U2.58
AEC: J2.9, U2.2 (I/O/GTS2)
BA: J2.21, U2.18
CASENB: J2.41, R16.2, U2.49
CHAREN: J2.25, U2.22
CHAROM: J2.46, R21.2, U2.57
CLK: J2.47, U2.15 (I/O/GCK1)
CLRBNK: J2.32, R7.2, U2.32
COLRAM: J2.45, R20.2, U2.56
DIR: J2.39, R14.2, U2.47
DMAACK: J2.8, U2.64 (I/O/GSR)
DWE: J2.40, R15.2, U2.46
FROM: J2.33, R8.2, U2.35
GAME: J2.11, U2.4
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, J1.2 (GND), J1.10 (GND), J2.24, R2.2, SW1.5, SW1.6, U1.1 (GND), U2.14 (GND), U2.21 (GND), U2.41 (GND), U2.54 (GND)
GWE: J2.44, R19.2, U2.52
HIRAM: J2.23, U2.20
IOACC: J2.43, R18.2, U2.51
IOCS: J2.38, R13.2, U2.48
IOSE: J2.16, U2.10
KERNAL_OVERRIDE: R1.1, SW1.2, U2.39
LORAM: J2.22, U2.19
unnamed: D1.1 (K), R4.1
unnamed: D2.1 (K), R5.1
unnamed: D3.1 (K), R6.1
unnamed: D4.1 (K), R7.1
unnamed: D5.1 (K), R8.1
unnamed: D6.1 (K), R9.1
unnamed: D7.1 (K), R10.1
unnamed: D8.1 (K), R11.1
unnamed: D9.1 (K), R12.1
unnamed: D10.1 (K), R13.1
unnamed: D11.1 (K), R14.1
unnamed: D12.1 (K), R15.1
unnamed: D13.1 (K), R16.1
unnamed: D14.1 (K), R17.1
unnamed: D15.1 (K), R18.1
unnamed: D16.1 (K), R19.1
unnamed: D17.1 (K), R20.1
unnamed: D18.1 (K), R21.1
PRIVATE_EYES: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), R2.1, SW1.3, U2.38
RBHI: J2.17, U2.11
RBLO: J2.18, U2.12
ROM1: J2.37, R12.2, U2.43
ROM2: J2.36, R11.2, U2.36
ROM3: J2.35, R10.2, U2.34
ROM4: J2.34, R9.2, U2.33
ROMH: J2.31, R6.2, U2.31
ROML: J2.30, R5.2, U2.27
RW: J2.10, U2.1
SDEN: J2.29, R4.2, U2.25
SLOW_EXP: R3.1, SW1.1, U2.40
TCK: J1.1 (TCK), U2.30 (TCK)
TDI: J1.9 (TDI), U2.28 (TDI)
TDO: J1.3 (TDO), U2.53 (TDO)
TMS: J1.5 (TMS), U2.29 (TMS)
VA14: J2.26, U2.23
VCC: FB1.2, J1.7 (VCC), J2.48
VIC: J2.42, R17.2, U2.50
VICFIX: J2.7, U2.16 (I/O/GCK2)
VMA4: J2.19, U2.13
VMA5: J2.20, U2.17 (I/O/GCK3)
XROM: J2.12, U2.6
Z80EN: J2.13, U2.7
Z80IO: J2.14, U2.8

Board: 2 copper layers, 17.4 x 60.6 mm, 51 parts (47 on the bottom side), 74 nets.

## KiCad design TexasInstruments-TI994A-32KB/kicad/sidecar.kicad_pcb

Board: 2 copper layers, 57.0 x 26.5 mm, 9 parts (0 on the bottom side), 42 nets.

Parts:
C1, C2, C3, C4, C5: 0.1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
H1: MountingHole; MountingHole_6.4mm_M6
J2: Conn_02x22_Odd_Even; PinSocket_2x22_P2.54mm_Vertical
U1: CY62256-70PC; SOIC-28W_7.5x17.9mm_P1.27mm
U2: ATF1502AS; TQFP-44_10x10mm_P0.8mm

Connections:
A0: J2.32, U2.27
A1: J2.29, U1.1, U2.28
A2: J2.19, U2.30
A3: J2.9, U1.2
A4: J2.8, U1.23
A5: J2.6, U1.21
A6: J2.30, U1.24
A7: J2.18, U1.25
A8: J2.13, U1.3
A9: J2.17, U1.4
A10: J2.5, U1.5
A11: J2.7, U1.6
A12: J2.12, U1.7
A13: J2.16, U1.8
A14: J2.15, U1.9
A15: J2.20, U1.10
D0: J2.38, U2.18
D1: J2.39, U2.19
D2: J2.40, U2.20
D3: J2.41, U2.21
D4: J2.36, U2.14
D5: J2.37, U2.15
D6: J2.35, U2.13
D7: J2.33, U2.12
DBIN: J2.10, U2.23
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J2.22, J2.24, J2.26, J2.28, U1.14, U2.4, U2.16, U2.24, U2.36, U2.38, U2.40
Q0: U1.19, U2.44
Q1: U1.18, U2.43
Q2: U1.17, U2.42
Q3: U1.16, U2.35
Q4: U1.15, U2.34
Q5: U1.13, U2.11
Q6: U1.12, U2.10
Q7: U1.11, U2.8
RA2: U1.26, U2.5
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, J2.2, U1.28, U2.9, U2.17, U2.29, U2.39, U2.41
~MEMEN: J2.31, U2.25
~PHI3: J2.23, U2.37
~RCS: U1.20, U2.2
~ROE: U1.22, U2.3
~RWE: U1.27, U2.6
~WE: J2.25, U2.22

## KiCad design Commodore-64-128-Diagnostic-Harness/Keyboard-Loopback-128-128D-SX64/kicad/keyboard.kicad_pcb

Board: 2 copper layers, 35.8 x 22.0 mm, 5 parts (0 on the bottom side), 18 nets.

Parts:
H1: MountingHole; MountingHole_6.4mm_M6
J1: DB25-M(X)/F(8); DSUB-25_Male_EdgeMount_P2.77mm
J2: DB25-M(8); DSUB-25_Female_EdgeMount_P2.77mm
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
SW1: SW_DPDT_x2; DPDT_Latching

Connections:
unnamed: J1.9, JP1.1 (A), SW1.5
unnamed: J1.10, J1.18
unnamed: J1.11, J1.19
unnamed: J1.12, J1.13
unnamed: J1.6, J1.14
unnamed: J1.7, J1.15
unnamed: J1.8, J1.16
unnamed: J1.5, J1.17
unnamed: J1.20, JP1.2 (B), SW1.6
unnamed: J2.1, J2.2
unnamed: J2.5, SW1.2
unnamed: J2.19, SW1.3
unnamed: J2.3, J2.20
unnamed: J2.4, J2.21
unnamed: J2.9, J2.22
unnamed: J2.6, J2.23
unnamed: J2.7, J2.24
unnamed: J2.8, J2.25

Notices in the files:
GenAssister/kicad/genesis-to-c64.kicad_pcb:
© 2022 BackBit
IBM-PCjr-512KB/kicad/sidecar.kicad_pcb:
© 2023  BackBit
Korg-01W-LCD-Fix/contrast.kicad_pcb:
© 2024  BackBit
